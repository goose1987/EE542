# Keil uVision project invert_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: invert_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h PWM_BUCK.c PWM_BUCK.h PWM_BUCK_PM.c cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h LCD_Char_1.c LCD_Char_1.h LCD_Char_1_PM.c LCD_Char_1_LCDPort_aliases.h LCD_Char_1_LCDPort.c LCD_Char_1_LCDPort.h ADC_DelSig_V.c ADC_DelSig_V.h ADC_DelSig_V_PM.c ADC_DelSig_V_INT.c ADC_DelSig_V_theACLK.c ADC_DelSig_V_theACLK.h ADC_DelSig_V_Ext_CP_Clk.c ADC_DelSig_V_Ext_CP_Clk.h ADC_DelSig_V_AMux.c ADC_DelSig_V_AMux.h UART_1.c UART_1.h UART_1_PM.c UART_1_INT.c UART_1_BOOT.c UART_1_IntClock.c UART_1_IntClock.h SPIS_1.c SPIS_1.h SPIS_1_PM.c SPIS_1_INT.c SPIS_1_BOOT.c Clock_3.c Clock_3.h BUCK_LS_aliases.h BUCK_LS.c BUCK_LS.h A_HS_aliases.h A_HS.c A_HS.h A_LS_aliases.h A_LS.c A_LS.h B_HS_aliases.h B_HS.c B_HS.h B_LS_aliases.h B_LS.c B_LS.h V_SENSE_aliases.h V_SENSE.c V_SENSE.h SS_aliases.h SS.c SS.h SCLK_aliases.h SCLK.c SCLK.h MOSI_aliases.h MOSI.c MOSI.h MISO_aliases.h MISO.c MISO.h BUCK_HS_aliases.h BUCK_HS.c BUCK_HS.h Control_Reg_1.c Control_Reg_1.h Clock_2.c Clock_2.h Counter_1.c Counter_1.h Counter_1_PM.c isr_LUT.c isr_LUT.h Clock_4.c Clock_4.h
target Release (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: as above
  output: invert_PSoC5lib (library)
